File: pcb/modbus_climate_control.kicad_pcb (KiCad board)
At the start: 2 copper layers, 3 parts

Commit message: named the pins
Other:
- net class Default removed
